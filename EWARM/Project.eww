<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SVF10-20170908.ewp</path>
  </project>
  <batchBuild />
</workspace>
